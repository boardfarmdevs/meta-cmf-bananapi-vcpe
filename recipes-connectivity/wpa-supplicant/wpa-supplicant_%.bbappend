SRC_URI_remove = "file://0001-remove-ubus-on-rdkb.patch"
