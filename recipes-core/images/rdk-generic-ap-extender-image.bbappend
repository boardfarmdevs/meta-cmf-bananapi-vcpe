# The extenders' image: ARP answered only on the interface that holds the address (as the
# gateway's, rdk-generic-broadband-image.bbappend).
require recipes-core/images/vcpe-arp-hardening.inc
