FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-wan-ipv6-prefer-sysevent.patch"
