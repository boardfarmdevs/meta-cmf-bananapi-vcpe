CFLAGS_append = " -I${STAGING_INCDIR}/utctx"
DEPENDS_append = " utopia-headers"
